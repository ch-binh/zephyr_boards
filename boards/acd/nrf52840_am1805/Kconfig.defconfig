## boards/acd/nrf52840_am1805/Kconfig.defconfig
```kconfig
if BOARD_NRF52840_AM1805

config BT_CTLR
	default BT
	
config BOARD
	default "selfdev_nrf52840dk"

endif # BOARD_NRF52840_AM1805
```
